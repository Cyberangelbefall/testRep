# Keil uVision project biye.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: biye +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Code\AD0832;.\Code\Uart;.\Code\Delay;.\Code\DHT11;.\Code\Lcd
  group Code
    ./Code/AD0832/: ad0832.c
    ./Code/Delay/: delay.c
    ./Code/DHT11/: dht11.c
    ./Code/Uart/: uart.c
    ./Code/Lcd/: lcd.c
  group User
    ./User/: main.c
